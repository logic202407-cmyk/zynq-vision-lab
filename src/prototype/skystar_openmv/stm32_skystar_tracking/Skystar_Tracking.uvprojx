# Keil uVision project Skystar_Tracking.uvprojx, settings and files
target Skystar_Tracking (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VE STMicroelectronics
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") CLOCK(16000000) ELITTLE
  output: skystar_tracking +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --fpu=SoftVFP --library_type=microlib
  c include: .\User;..\stm32_project\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\firmware.sct
  link misc: --library_type=microlib
  group Skystar tracking and reused PID
    ./: startup.s
    User/: main.c board.c tracking.c safety.c
    ../stm32_project/User/: pid.c
