# Keil uVision project Project.uvprojx, settings and files
target STM32 P0 independent v1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(8000000) ELITTLE
  output: STM32_P0 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\User;..\..\..\..\private\stm32-deps\Start;..\..\..\..\private\stm32-deps\Library
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./User/: command.c command.h control.c control.h main.c pid.c pid.h rx_queue.c rx_queue.h servo.c servo.h stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h uart_parser.c uart_parser.h usart3_config.c usart3_config.h usart_config.c usart_config.h
  group Dependencies
    ../../../../private/stm32-deps/Start/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h startup_stm32f10x_md.s
    ../../../../private/stm32-deps/Library/: misc.c misc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h
